# Repository ElektroNeo/Modular-Development-Board

File README.md:

# Modular-Development-Board
Arduino based Modular Development Board.

It has 4 breakable module;
- Humidity - Temperature Sensor and LED Module
- Light Sensor and Buzzer Module
- Power Module
- TTL to UART Converter Module

<<<<<<< HEAD

=======

## KiCad design KiCAD/modular-development-board/modular-development-board.kicad_pcb

Parts:
BZ1: Buzzer; Buzzer_12x9.5RM7.6
C1, C2, C4: 100nF 50V; C_0805_2012Metric_Pad1.15x1.40mm_HandSolder
C3: 4.7uF 10V; C_0805_2012Metric_Pad1.15x1.40mm_HandSolder
C5: 22uF 25V; C_0805_2012Metric_Pad1.15x1.40mm_HandSolder
C6, C7: 10uF 10V; C_0805_2012Metric_Pad1.15x1.40mm_HandSolder
C8, C9: 10nF 50V; C_0805_2012Metric_Pad1.15x1.40mm_HandSolder
C10, C11: 18pF; C_0805_2012Metric_Pad1.15x1.40mm_HandSolder
D1: CDBA240LL-G; D_SMA_Handsoldering
D2, D3: LED; LED_0805_2012Metric_Pad1.15x1.40mm_HandSolder
D4: GREEN; LED_0805_2012Metric_Pad1.15x1.40mm_HandSolder
D5: YELLOW; LED_0805_2012Metric_Pad1.15x1.40mm_HandSolder
D6: RED; LED_0805_2012Metric_Pad1.15x1.40mm_HandSolder
F1: FSMD200-242920-R; Fuse_2920_7451Metric_Pad2.10x5.45mm_HandSolder
H1, H2, H3, H4: M4; MountingHole_2.2mm_M2_Pad_Via
J1: Power In; BarrelJack_Horizontal
J2: 5V Out; PinSocket_1x03_P2.54mm_Vertical
J3: 3V3 Out; PinSocket_1x03_P2.54mm_Vertical
J4: GND; PinSocket_1x03_P2.54mm_Vertical
J5: Digital 1; PinSocket_1x08_P2.54mm_Vertical
J6: Digital 2; PinSocket_1x07_P2.54mm_Vertical
J7: Analog; PinSocket_1x08_P2.54mm_Vertical
J8: Power; PinSocket_1x05_P2.54mm_Vertical
J9: ICSP; PinHeader_2x03_P2.54mm_Vertical
J10: DHT11-LEDS; PinSocket_1x06_P2.54mm_Vertical
J11: Buzzzer-Light; PinSocket_1x04_P2.54mm_Vertical
J12: USB_B_Micro; KLS1-233-Micro-USB
J13: UART; PinHeader_1x04_P2.54mm_Vertical
J14: Power In; PinSocket_1x02_P2.54mm_Vertical
JP1: LIGHT; SolderJumper-2_P1.3mm_Open_RoundedPad1.0x1.5mm
JP2: BUZZER; SolderJumper-2_P1.3mm_Open_RoundedPad1.0x1.5mm
JP3: DHT11; SolderJumper-2_P1.3mm_Open_RoundedPad1.0x1.5mm
JP4: LED_G; SolderJumper-2_P1.3mm_Open_RoundedPad1.0x1.5mm
JP5: LED_Y; SolderJumper-2_P1.3mm_Open_RoundedPad1.0x1.5mm
JP6: LED_R; SolderJumper-2_P1.3mm_Open_RoundedPad1.0x1.5mm
Q1: ALS-PT19-315C; D_0805_2012Metric_Pad1.15x1.40mm_HandSolder
Q2: 2N2222; SOT-23_Handsoldering
R1, R3: 1k; R_0805_2012Metric_Pad1.15x1.40mm_HandSolder
R2, R6: 1K; R_0805_2012Metric_Pad1.15x1.40mm_HandSolder
R4, R5: 22; R_0805_2012Metric_Pad1.15x1.40mm_HandSolder
R7, R8, R9: 330; R_0805_2012Metric_Pad1.15x1.40mm_HandSolder
R10, R11: 4k7; R_0805_2012Metric_Pad1.15x1.40mm_HandSolder
SW1: RESET; SW_SPST_CK_RS282G05A3
U1: ATmega328P-AU; TQFP-32_7x7mm_P0.8mm
U2: AMS1117-5.0; SOT-223-3_TabPin2
U3: AMS1117-3.3; SOT-223-3_TabPin2
U4: CH340G; SOIC-16_3.9x9.9mm_P1.27mm
U5: DHT11; Aosong_DHT11_5.5x12.0_P2.54mm
Y1: 16MHz; Crystal_SMD_5032-4Pin_5.0x3.2mm
Y2: 12MHz; Crystal_SMD_5032-2Pin_5.0x3.2mm_HandSoldering

Connections:
+3V3: C7.1, J3.1, J3.2, J3.3, U3.2 (VO)
+5V: BZ1.1 (-), C2.1, C3.1, C4.1, C6.1, D3.2 (A), J2.1, J2.2, J2.3, J8.2, J8.3, J9.2, J10.1, J11.1, J13.1, R2.1, R6.1, R11.1, U1.4 (VCC), U1.6 (VCC), U1.18 (AVCC), U2.2 (VO), U3.3 (VI), U4.16 (VCC), U5.1 (VCC)
/A0: J7.1, U1.23 (PC0)
/A1: J7.2, U1.24 (PC1)
/A2: J7.3, U1.25 (PC2)
/A3: J7.4, U1.26 (PC3)
/A4: J7.5, U1.27 (PC4)
/A5: J7.6, U1.28 (PC5)
/A6: J7.7, U1.19 (ADC6)
/A7: J7.8, U1.22 (ADC7)
/AREF: C1.1, J8.1, U1.20 (AREF)
/BUZZER: J11.3, JP2.1 (A), R10.2
/D0: J5.1, J13.2, U1.30 (PD0), U4.2 (TXD)
/D1: J5.2, J13.3, U1.31 (PD1), U4.3 (RXD)
/D2: J5.3, U1.32 (PD2)
/D3: J5.4, U1.1 (PD3)
/D4: J5.5, U1.2 (PD4)
/D5: J5.6, U1.9 (PD5)
/D6: J5.7, JP3.2 (B), U1.10 (PD6)
/D7: J5.8, JP4.2 (B), U1.11 (PD7)
/D8: J6.1, JP5.2 (B), U1.12 (PB0)
/D9: J6.2, JP6.2 (B), U1.13 (PB1)
/D10: J6.3, JP1.2 (B), U1.14 (PB2)
/D11: J6.4, J9.4, U1.15 (PB3)
/D12: J6.5, J9.1, U1.16 (PB4)
/D13: J6.6, J9.3, JP2.2 (B), R1.2, U1.17 (PB5)
/D+: R4.1, U4.5 (UD+)
/D-: R5.1, U4.6 (UD-)
/DHT11: J10.2, JP3.1 (A), R11.2, U5.2 (IO)
/LED_G: J10.3, JP4.1 (A), R7.2
/LED_R: J10.5, JP6.1 (A), R9.2
/LED_Y: J10.4, JP5.1 (A), R8.2
/LIGHT: J11.2, JP1.1 (A), Q1.1 (C), R6.2
/RESET: C9.1, J6.7, J9.5, R2.2, SW1.1 (A), U1.29 (~RESET~/PC6)
/XI: C10.1, U4.7 (XI), Y2.1
/XO: C11.1, U4.8 (XO), Y2.2
/XTAL1: U1.7 (XTAL1/PB6), Y1.2
/XTAL2: U1.8 (XTAL2/PB7), Y1.4
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, C10.2, C11.2, D2.1 (K), D4.1 (K), D5.1 (K), D6.1 (K), H1.1, H2.1, H3.1, H4.1, J1.2, J1.3, J4.1, J4.2, J4.3, J8.4, J8.5, J9.6, J10.6, J11.4, J12.4 (ID), J12.5 (GND), J12.6 (Shield), J13.4, J14.2, Q1.2 (E), Q2.3 (E), R3.1, SW1.2 (B), U1.3 (GND), U1.5 (GND), U1.21 (GND), U2.1 (GND), U3.1 (GND), U4.1 (GND), U5.4 (GND), Y1.1, Y1.3
unnamed: BZ1.2 (+), Q2.1 (C)
unnamed: C8.1, U4.4 (V3)
unnamed: C9.2, U4.13 (~DTR)
unnamed: D1.1 (K), F1.2
unnamed: D1.2 (A), J1.1, J14.1
unnamed: D2.2 (A), R1.1
unnamed: D3.1 (K), R3.2
unnamed: D4.2 (A), R7.1
unnamed: D5.2 (A), R8.1
unnamed: D6.2 (A), R9.1
unnamed: J12.2 (D-), R5.2
unnamed: J12.3 (D+), R4.2
unnamed: Q2.2 (B), R10.1
VCC: C5.1, F1.1, U2.3 (VI)

Notes on the sheet:
USB - TTL Converter
USB Connector
Power
Microcontroller
Connectors
DHT11 Sensor
ICSP
Buzzer
Light Sensor
Power LED
Vf=0.35V
Hold Current = 2A Trip Current = 4A
TODO: Add VBUS to the 5V rail with schotky diode.
TODO: 16MHz Osc Error - 2 and 4 must be GND (reverse them).
TODO: Add TX and RX LEDs.
TODO: Increase Power LED resistor to 4.7k.
TODO: Add 1k to TX and RX line.
TODO: Incorrect 2N2222 in PCB.
TODO: Connect LIGHT to Analog 0 pin. Change resistor position.
TODO: Connect Buzzer to different pin.

Board: 2 copper layers, 79.0 x 79.0 mm, 64 parts (6 on the bottom side), 53 nets.

## Commit log

2020-07-12 Added breakable board files.
2020-07-12 Added research proposal.
2020-09-28 Change hole size.
2020-09-28 Added modular development board design files.
2020-09-28 Set theme jekyll-theme-tactile
2020-12-26 Added modular developmend board design and test software.
